# Keil uVision project Baloon1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Baloon1
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./Src/: main.c system_stm32l1xx.c Retarget.c Serial.c startup_stm32l1xx_mdp.s SPI.c Si446x.c Timers.c USART.c I2C.c GPS.c RTC.c
